FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Purpose-Support-simulate-button-for-power-control.patch;patchdir=.."


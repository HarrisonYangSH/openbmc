FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Purpose-Fix-wrong-RGB-offset-with-TC358743.patch \
            file://0002-Purpose-Make-Obmc-iKVM-can-work-with-Raspberry-Pi-4-.patch \
            "


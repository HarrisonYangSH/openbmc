PACKAGECONFIG = "24bpp jpeg lzo systemd zlib openssl pthread"
